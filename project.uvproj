# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Hardware;.\System
  group Hardware
    ./Hardware/: Digital_LED.c Digital_LED.h Key.c Key.h
  group System
    ./System/: delay.c delay.h Timer0.c Timer0.h
  group main
    ./: main.c
